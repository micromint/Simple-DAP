# Keil uVision project lpc11u35_dap.uvproj, settings and files
target lpc11u35_dap (ARM-ADS)
  device: LPC11U35/501 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lpc11u35_dap +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe --bin --output .\Obj\lpc11u35_dap.bin .\Obj\lpc11u35_dap.axf
  c flags: Optim=3
  c define: TARGET_LPC11U35, BOARD_BAMBINO_210E
  c include: ..\..\Common\inc;..\..\Common\src;..\..\..\shared\USBStack\INC;..\..\interface\hal\TARGET_NXP\TARGET_LPC11U35;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC11UXX\TOOLCHAIN_ARM_STD\LPC11U35.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/: system_LPC11Uxx.c
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC11UXX/TOOLCHAIN_ARM_STD/: startup_LPC11Uxx.s
  group Common
    ../../../interface/Common/src/: DAP.c JTAG_DP.c main.c SW_DP.c usb_config.c usbd_user_hid.c
  group HAL-Interface
    ../../../interface/interface/hal/TARGET_NXP/TARGET_LPC11U35/: DAP_config.h usbd_LPC11Uxx.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
