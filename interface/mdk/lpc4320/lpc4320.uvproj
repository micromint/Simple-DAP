# Keil uVision project lpc4320.uvproj, settings and files
target lpc4320_dap (ARM-ADS)
  device: LPC4320 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x20003FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lpc4320_dap
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe --bin --output .\Obj\lpc4320_dap.bin .\Obj\lpc4320_dap.axf
  c flags: Optim=3
  c define: TARGET_LPC4320, CONF_DAP, BOARD_LPCLINK_2
  c include: ..\..\Common\inc;..\..\Common\src;..\..\..\shared\USBStack\INC;..\..\interface\hal\TARGET_NXP\TARGET_LPC4320;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC43XX
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\shared\cmsis\TARGET_NXP\TARGET_LPC43XX\TOOLCHAIN_ARM_STD\LPC4320_SPIFI.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC43XX/: system_LPC43xx.c
    ../../../shared/cmsis/TARGET_NXP/TARGET_LPC43XX/TOOLCHAIN_ARM_STD/: startup_LPC43xx.s
  group Common
    ../../../interface/Common/src/: DAP.c JTAG_DP.c main.c SW_DP.c usbd_user_hid.c
    ../../Common/src/: usb_config_hs.c usbd_user_cdc_acm.c
  group HAL-Interface
    ../../../interface/interface/hal/TARGET_NXP/TARGET_LPC4320/: DAP_config.h usbd_LPC43xx_USB0.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_hid.c
target lpc4320_cdc (ARM-ADS)
  device: LPC4320 NXP (founded by Philips)
  cpu: as above
  output: lpc4320_dap
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: as above
  c flags: Optim=3
  c define: TARGET_LPC4320, CONF_DAP, BOARD_LPCLINK_2
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: as above
