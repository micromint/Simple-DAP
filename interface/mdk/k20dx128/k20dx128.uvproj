# Keil uVision project k20dx128.uvproj, settings and files
target k20dx128_dap (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx128_dap
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe --bin --output .\Obj\k20dx128_dap.bin .\Obj\k20dx128_dap.axf
  c flags: Optim=3
  c define: TARGET_MK20D5, CONF_DAP, BOARD_FRDM_K20D50M, INTERFACE_GEN_32KHZ
  c include: ..\..\Common\inc;..\..\Common\src;..\..\..\shared\USBStack\INC;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/: system_MK20D5.c
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/TOOLCHAIN_ARM_STD/: startup_MK20D5.s
  group Common
    ../../Common/src/: DAP.c main.c SW_DP.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c
  group HAL-Interface
    ../../interface/hal/TARGET_Freescale/TARGET_MK20DX/: DAP_config.h usbd_MK20D5.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_hid.c
target k20dx128_cdc (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_dap
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: as above
  c flags: Optim=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
